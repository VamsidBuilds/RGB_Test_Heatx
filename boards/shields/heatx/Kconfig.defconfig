## boards/shields/heatx/Kconfig.defconfig
```kconfig
if SHIELD_HEATX

config ZMK_KEYBOARD_NAME
    default "heatx"

endif # SHIELD_HEATX
```
